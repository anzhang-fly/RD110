# Keil uVision project DMA.uvprojx, settings and files
target DMA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DMA +hex
  AfterMake: E:\MDKKeil5\ARM\ARMCC\bin\fromelf.exe  --bin -o  ..\GLDSV9.3.4(GD).bin ..\OBJ\DMA.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,saw_f_2
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\HP206C;..\HARDWARE\STMFLASH;..\HARDWARE\IIC;..\HARDWARE\SHT20;..\HARDWARE\CJSON;..\HARDWARE\MCP4017
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c OURS.c OURS.h
  group HARDWARE
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/HP206C/: bsp_i2c_gpio.c sensor.c sensor303.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/SHT20/: SHT2X.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/CJSON/: cJSON.c
    ../HARDWARE/MCP4017/: mcp4017.c
    ../HARDWARE/IIC/: myiic.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_dac.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_flash.c
  group README
    ../: README.TXT
